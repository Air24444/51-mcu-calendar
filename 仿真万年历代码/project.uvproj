# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h DS1302.c DS1302.h DS18B20.h DS18B20.c AT24C512.h AT24C512.c Key.h Key.c Lunar.h Lunar.c DeviceCtrl.h DeviceCtrl.c delay.c delay.h i2c.c i2c.h
